# IAR project stm8-ntc-temperature-display-DSN_VC288.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.PreInclude: ..\pre-config.h
  ICCSTM8.CCIncludePath2: ..\lib\!mcu\include; ..\lib\!stm8\include; ..\lib\!cpp\include
  ICCSTM8.IccLang: 2
  OBJCOPY.OOCOutputFile: stm8-ntc-temperature-display-DSN_VC288.srec
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: NDEBUG
  group src
    ../src/: main.cpp
  group !hal
    ../lib/!stm8/lib/: delay.c
